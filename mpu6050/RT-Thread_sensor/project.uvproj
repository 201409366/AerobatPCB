# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F401VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1
  c define: RT_USING_ARM_LIBC, STM32F401xx, USE_STDPERIPH_DRIVER
  c include: applications;.;drivers;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\CMSIS\Device\ST\STM32F4xx\Include;Libraries\CMSIS\Include;Libraries\CMSIS\RTOS;sensors;..\..\..\rt-thread\rt-thread-2.0.1\components\drivers\sensors;..\..\..\rt-thread\rt-thread-2.0.1\components\drivers\include;..\..\..\rt-thread\rt-thread-2.0.1\include;..\..\..\rt-thread\rt-thread-2.0.1\libcpu\arm\cortex-m4;..\..\..\rt-thread\rt-thread-2.0.1\libcpu\arm\common;..\..\..\rt-thread\rt-thread-2.0.1\components\cplusplus;..\..\..\rt-thread\rt-thread-2.0.1\components\drivers\include;..\..\..\rt-thread\rt-thread-2.0.1\components\drivers\include;..\..\..\rt-thread\rt-thread-2.0.1\components\drivers\spi;..\..\..\rt-thread\rt-thread-2.0.1\components\drivers\include;..\..\..\rt-thread\rt-thread-2.0.1\components\drivers\include;..\..\..\rt-thread\rt-thread-2.0.1\components\finsh;..\..\..\rt-thread\rt-thread-2.0.1\components\init;..\..\..\rt-thread\rt-thread-2.0.1\components\libc\armlibc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(FSymTab)  --keep __rt_init*
  group Applications
    applications/: application.c sensor_test.c startup.c
  group Drivers
    drivers/: board.c stm32_i2c.c usart.c
  group STM32_StdPeriph
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp_aes.c stm32f4xx_cryp.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
  group Sensors
    sensors/: bmi055_sensor.cpp mpu6050_sensor.cpp mpu6500_sensor.cpp
    ../../../rt-thread/rt-thread-2.0.1/components/drivers/sensors/: sensor.cpp
  group Kernel
    ../../../rt-thread/rt-thread-2.0.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../rt-thread/rt-thread-2.0.1/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../rt-thread/rt-thread-2.0.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group CPlusPlus
    ../../../rt-thread/rt-thread-2.0.1/components/cplusplus/: crt.cpp crt_init.c
  group DeviceDrivers
    ../../../rt-thread/rt-thread-2.0.1/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../rt-thread/rt-thread-2.0.1/components/drivers/serial/: serial.c
    ../../../rt-thread/rt-thread-2.0.1/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../rt-thread/rt-thread-2.0.1/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../rt-thread/rt-thread-2.0.1/components/finsh/: shell.c symbol.c cmd.c msh_cmd.c msh.c
  group Components
    ../../../rt-thread/rt-thread-2.0.1/components/init/: components.c
  group libc
    ../../../rt-thread/rt-thread-2.0.1/components/libc/armlibc/: mem_std.c stubs.c

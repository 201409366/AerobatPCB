# Keil uVision project STM32-DEMO.uvproj, settings and files
target STM32-DEMO (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\USER;..\FWlib\inc;..\CMSIS;..\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c usart1.c nRF24L01.c led.c spi.c rtc.c SysTick.c
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_bkp.c misc.c stm32f10x_pwr.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
